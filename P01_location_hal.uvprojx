# Keil uVision project P01_location_hal.uvprojx, settings and files
target P01_location_hal (5060960::V5.06 update 7 (build 960)::.\arm5_compiler)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: P01_location_hal +hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;./common;./interface;./interface/lora;./application
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group common
    ./common/: Com_debug.c Com_debug.h Com_Filter.c Com_Filter.h cJSON.c cJSON.h
  group interface
    ./interface/: Int_led.c Int_led.h Int_buzzer.c Int_buzzer.h Int_step.c Int_step.h Int_AT6558R.c Int_AT6558R.h Int_mpu6050.c Int_mpu6050.h Int_qs100.c Int_qs100.h
  group lora
    ./interface/lora/: driver_llcc68.c driver_llcc68.h driver_llcc68_interface.c driver_llcc68_interface.h Int_llcc68.c Int_llcc68.h
  group application
    ./application/: App_upload_data.c App_upload_data.h App_warning.c App_warning.h
software components: CMSIS:CORE 4.3.0
